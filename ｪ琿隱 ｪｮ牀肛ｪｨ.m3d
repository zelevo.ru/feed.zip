# KOMPAS-3D part (ｪ琿隱  ｪｮ牀肛ｪｨ.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 2
3. Эскиз:2
4. Операция выдавливания:2
     Расстояние 1 = 3
